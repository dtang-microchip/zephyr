## boards/atmel/sam0/samd21_samiot/board.yml
```yaml
board:
  name: samd21_samiot
  full_name: SAM D21 SAM IOT
  vendor: atmel
  socs:
    - name: samd21g18a
```
